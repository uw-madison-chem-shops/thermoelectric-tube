# Repository uw-madison-chem-shops/thermoelectric-tube

File README.md:

# Thermoelectric Tube

A small project for students to put together as a learning exercise.
Involves machining, glass blowing, and electronics work.

## Repository

This is an open source hardware project licensed under the CERN Open Hardware License Version 2 - Permissive.
Please see the LICENSE file for the complete license.

This repository is being mirrored to several version control systems in an attempt to ensure maximum availability.

| name             | url                                                                          |
| ---------------- | ---------------------------------------------------------------------------- |
| blaise           | https://git.blaise.zone/uw-madison-chem-shops/thermoelectric-tube.git/about/ | 
| Codeburg         | https://codeberg.org/uw-madison-chem-shops/thermoelectric-tube               |
| GitHub (primary) | https://github.com/uw-madison-chem-shops/thermoelectric-tube                 |
| GitLab           | https://gitlab.com/uw-madison-chem-shops/thermoelectric-tube                 |

## KiCad design pcb/thermoelectric-tube.kicad_pcb

File pcb/README.md:

# Thermoelectric Tube PCB

Circuit board for thermoelectric tube project.

## PCB

This PCB was designed using KiCAD version 5.
Refer to `thermoelectric-tube.pdf` for schematic.
PCB images generated with [tracespace](https://github.com/tracespace/tracespace) follow.

Bill of Materials

| reference      | value         | manufacturer | part number          | price | vendors |
| :------------- | :------------ | :----------- | :------------------- | :---- | :------ |

## Changelog

### Unprinted

### Revision B

#### Added
- fans
- proper connector for peltier element

### Revision A

#### Added
- initial design

Parts:
C1: 100u; CP_Radial_D7.5mm_P2.50mm
C2: 10u; C_Radial_D6.3mm_H5.0mm_P2.50mm
C3: 22u; C_Radial_D6.3mm_H5.0mm_P2.50mm
C4, C5: 20p; C_Radial_D6.3mm_H5.0mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_D5.0mm
J1: Barrel_Jack; BarrelJack_Horizontal
M1, M2: Fan; F17HA-05HC
PE1: Peltier_Element; Molex_Mini-Fit_Jr_5566-02A_2x01_P4.20mm_Vertical
PS1: VXO7805-500-M; CONV_VXO7805-500-M
Q1, Q4: 2N3904; TO-92_Inline_Wide
Q2, Q5: IRF9630; TO-220-3_Vertical
Q3, Q6: IRF630; TO-220-3_Vertical
R1, R2, R4, R5, R7, R8, R9, R11, R12, R13: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R6: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1, SW2: SW_Push; PTS636
TP1, TP2, TP3, TP4, TP5: TestPoint; TestPoint_Loop_D2.60mm_Drill1.6mm_Beaded
U1: ATmega328-P; DIP-28_W7.62mm
Y1: 16MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C3.1, PS1.3 (+VO), R1.1, TP5.1, U1.7 (VCC)
+12V: C1.1, C2.1, J1.1, M1.1 (+), M2.1 (+), PS1.1 (+VIN), Q2.3 (S), Q5.3 (S), R4.2, R5.1, TP1.1
COOL: R6.2, R7.2, U1.15 (PB1)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J1.2, M1.2 (-), M2.2 (-), PS1.2 (GND), Q1.1 (E), Q3.3 (S), Q4.1 (E), Q6.3 (S), SW1.2, SW2.2, TP2.1, U1.8 (GND), U1.22 (GND)
HEAT: R2.2, R3.1, U1.16 (PB2)
unnamed: C4.1, R10.1, U1.9 (XTAL1/PB6), Y1.2
unnamed: C5.2, R10.2, U1.10 (XTAL2/PB7), Y1.1
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R7.1
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
unnamed: D6.2 (A), R11.2
unnamed: D7.2 (A), R12.2
unnamed: D8.2 (A), R13.2
unnamed: PE1.1, Q5.2 (D), Q6.2 (D), TP3.1
unnamed: PE1.2, Q2.2 (D), Q3.2 (D), TP4.1
unnamed: Q1.2 (B), R3.2
unnamed: Q2.1 (G), Q3.1 (G), Q4.3 (C), R5.2
unnamed: Q4.2 (B), R6.1
unnamed: Q1.3 (C), Q5.1 (G), Q6.1 (G), R4.1
unnamed: R8.1, U1.13 (PD7)
unnamed: R9.1, U1.12 (PD6)
unnamed: R11.1, U1.11 (PD5)
unnamed: R12.1, U1.6 (PD4)
unnamed: R13.1, U1.5 (PD3)
unnamed: SW1.1, U1.2 (PD0)
unnamed: SW2.1, U1.3 (PD1)

Notes on the sheet:
PELTIER
CONTROL
COOLING
POWER

Board: 2 copper layers, 142.2 x 91.4 mm, 46 parts (0 on the bottom side), 28 nets.

## KiCad design PCB/thermoelectric-tube.kicad_pcb

Parts:
C1: CP1; CP_Radial_D7.5mm_P2.50mm
C2: 100n; C_Radial_D6.3mm_H5.0mm_P2.50mm
D1, D2, D3: LED; LED_D5.0mm
J1: Barrel_Jack; BarrelJack_Horizontal
PE1: Peltier_Element; SolderWirePad_1x02_P5.08mm_Drill1.5mm
Q1, Q4: 2N3904; TO-92_Inline_Wide
Q2, Q5: IRF9630; TO-220-3_Vertical
Q3, Q6: IRF630; TO-220-3_Vertical
R1, R2, R3, R7: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R5: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: R_US; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
TC1: Thermocouple; SolderWirePad_1x02_P5.08mm_Drill1.5mm
U1: AD595AQ; DIP-14_W7.62mm_Socket_LongPads
XA1: Arduino_Micro_Socket

Connections:
+3V3: XA1.3V3 (3.3V)
+5V: C2.2, U1.11 (V+), XA1.5V
+12V: C1.1, J1.1, Q2.3 (S), Q5.3 (S), R1.2, R4.2, R5.1, XA1.VIN
GND: C1.2, C2.1, D1.1 (K), D2.1 (K), D3.1 (K), J1.2, Q1.1 (E), Q3.3 (S), Q4.1 (E), Q6.3 (S), TC1.1 (+), U1.1 (+IN), U1.4 (COM), U1.7 (V-), U1.13 (-ALM), XA1.GND1 (GND), XA1.GND2 (GND)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R7.1
unnamed: PE1.1, Q5.2 (D), Q6.2 (D)
unnamed: PE1.2, Q2.2 (D), Q3.2 (D)
unnamed: Q1.2 (B), R3.2
unnamed: Q1.3 (C), Q5.1 (G), Q6.1 (G), R4.1
unnamed: Q2.1 (G), Q3.1 (G), Q4.3 (C), R5.2
unnamed: Q4.2 (B), R6.1
unnamed: R2.2, R3.1, XA1.D12
unnamed: R6.2, R7.2, XA1.D11
unnamed: TC1.2 (-), U1.14 (-IN)
unnamed: U1.8 (FB), U1.9 (VO), XA1.A0

Notes on the sheet:
HEAT
COOL

Board: 2 copper layers, 127.0 x 76.2 mm, 23 parts (0 on the bottom side), 16 nets.

## Commit log

2021-07-26 fans
2021-07-27 revB
2021-07-27 LICENSE
2021-07-27 coverart
2021-08-04 remotes
2023-03-21 catchup
